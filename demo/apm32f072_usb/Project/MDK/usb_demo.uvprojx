# Keil uVision project usb_demo.uvprojx, settings and files
target APM32F072 (6140001::V6.14.1::ARMCLANG)
  device: APM32F072RB Geehy
  pack: Geehy.APM32F0xx_DFP.1.0.7
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: usb_demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: APM32F072xB
  c include: ..\..\Include;..\..\Library\CMSIS\Include;..\..\Library\Device\Geehy\APM32F0xx\Include;..\..\Library\APM32F0xx_StdPeriphDriver\inc;..\..\..\..\common;..\..\..\..\core;..\..\..\..\class\msc;..\..\..\..\class\hid;..\..\..\..\class\cdc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application
    ../../Source/: main.c apm32f0xx_int.c usb_dc_config.c
    ../../Include/: main.h apm32f0xx_int.h usb_config.h
    ../../../: hid_mouse_template.c msc_ram_template.c cdc_acm_template.c
  group StdPeriphDriver
    ../../Library/APM32F0xx_StdPeriphDriver/src/: apm32f0xx_adc.c apm32f0xx_can.c apm32f0xx_cec.c apm32f0xx_comp.c apm32f0xx_crc.c apm32f0xx_crs.c apm32f0xx_dac.c apm32f0xx_dbg.c apm32f0xx_dma.c apm32f0xx_eint.c apm32f0xx_fmc.c apm32f0xx_gpio.c apm32f0xx_i2c.c apm32f0xx_iwdt.c apm32f0xx_misc.c apm32f0xx_ob.c apm32f0xx_pmu.c apm32f0xx_rcm.c apm32f0xx_rtc.c apm32f0xx_spi.c apm32f0xx_syscfg.c apm32f0xx_tmr.c apm32f0xx_usart.c apm32f0xx_wwdt.c
  group CMSIS
    ../../Library/Device/Geehy/APM32F0xx/Source/: system_apm32f0xx.c
    ../../Library/Device/Geehy/APM32F0xx/Source/arm/: startup_apm32f072.s
    ../../Library/Device/Geehy/APM32F0xx/Include/: apm32f0xx.h system_apm32f0xx.h
  group cherry_usb/port/fsdev
    ../../../../port/fsdev/: usb_dc_fsdev.c usb_fsdev_reg.h
  group cherry_usb/core
    ../../../../core/: usbd_core.c usbd_core.h
  group cherry_usb/common
    ../../../../common/: usb_dc.h usb_def.h usb_errno.h usb_list.h usb_mem.h usb_util.h
  group cherry_usb/class/hid
    ../../../../class/hid/: usb_hid.h usbd_hid.c usbd_hid.h
  group cherry_usb/class/msc
    ../../../../class/msc/: usb_msc.h usb_scsi.h usbd_msc.c usbd_msc.h
  group cherry_usb/class/cdc
    ../../../../class/cdc/: usb_cdc.h usbd_cdc.c usbd_cdc.h
