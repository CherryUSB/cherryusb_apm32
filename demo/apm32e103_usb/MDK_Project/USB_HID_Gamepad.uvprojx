# Keil uVision project USB_HID_Gamepad.uvprojx, settings and files
target APM32E103_MINI (6140001::V6.14.1::ARMCLANG)
  device: APM32E103ZE Geehy
  pack: Geehy.APM32E1xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USB_HID_Gamepad +hex
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: APM32E10X_HD,APM32E103_MINI
  c include: ..\inc;..\Board;..\src\usbCore;..\Library\Device\Geehy\APM32E10x\Include;..\Library\CMSIS\Include;..\Library\APM32E10x_StdPeriphDriver\inc;..\..\apm32e103_usb;..\..\..\common;..\..\..\core;..\..\..\class\hid;..\..\..\class\msc;..\..\..\class\cdc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ../src/: main.c apm32e10x_it.c
    ../inc/: main.h apm32e10x_it.h
    ../../: hid_mouse_template.c msc_ram_template.c cdc_acm_msc_template.c
  group Board
    ../Board/: Board.c Board.h
  group StdPeriphDriver
    ../Library/APM32E10x_StdPeriphDriver/src/: apm32e10x_adc.c apm32e10x_bakpr.c apm32e10x_can.c apm32e10x_crc.c apm32e10x_dac.c apm32e10x_dbgmcu.c apm32e10x_dma.c apm32e10x_dmc.c apm32e10x_eint.c apm32e10x_emmc.c apm32e10x_fmc.c apm32e10x_gpio.c apm32e10x_i2c.c apm32e10x_iwdt.c apm32e10x_misc.c apm32e10x_pmu.c apm32e10x_rcm.c apm32e10x_rtc.c apm32e10x_sci2c.c apm32e10x_sdio.c apm32e10x_spi.c apm32e10x_tmr.c apm32e10x_usart.c apm32e10x_usb.c apm32e10x_wwdt.c
  group CMSIS
    ../Library/Device/Geehy/APM32E10x/Source/ARM/: startup_apm32e10x_hd.s
    ../Library/Device/Geehy/APM32E10x/Include/: apm32e10x.h system_apm32e10x.h
    ../Library/Device/Geehy/APM32E10x/Source/: system_apm32e10x.c
  group usb_port
    ../src/usbport/: usb_dc.c usb_power.c usb_power.h
  group cherry_usb/port/fsdev
    ../../../port/fsdev/: usb_dc_fsdev.c usb_fsdev_reg.h
    ../inc/: usb_config.h
    ../src/: usb_dc_config.c
  group cherry_usb/core
    ../../../core/: usbd_core.c usbd_core.h
  group cherry_usb/common
    ../../../common/: usb_dc.h usb_def.h usb_errno.h usb_list.h usb_mem.h usb_util.h
  group cherry_usb/class/hid
    ../../../class/hid/: usb_hid.h usbd_hid.c usbd_hid.h
  group cherry_usb/class/msc
    ../../../class/msc/: usbd_msc.h usbd_msc.c usb_scsi.h usb_msc.h
  group cherry_usb/class/cdc
    ../../../class/cdc/: usb_cdc.h usbd_cdc.c usbd_cdc.h
